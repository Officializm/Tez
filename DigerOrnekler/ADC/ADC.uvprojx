# Keil uVision project ADC.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADC
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX, HSE_VALUE=8000000
  c include: ..\ADC
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
